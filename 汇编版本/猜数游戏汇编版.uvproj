# Keil uVision project 猜数游戏汇编版.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: 猜数游戏汇编版
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.asm init_device.asm init_device.inc LCD12864.asm LCD12864.inc KEYBOARD.asm KEYBOARD.inc TIME.asm TIME.inc DISPLAY.asm DISPLAY.inc GUESSING_GAME.asm GUESSING_GAME.inc PICTURE.asm
    C:/Keil_v5/C51/LIB/: c51ms.lib
