# Keil uVision project 猜数游戏.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: 猜数游戏 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c init_device.c LCD12864.c LCD12864.h keyboard.c keyboard.h time.c time.h display.c display.h guessing_game.c guessing_game.h picture.c
